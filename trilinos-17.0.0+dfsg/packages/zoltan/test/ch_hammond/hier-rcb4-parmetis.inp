LB_METHOD HIER
2
0 0 1 1 2 2 3 3
LB_METHOD RCB
LEVEL END
0 1 0 1 0 1 0 1
LB_METHOD PARMETIS
PARMETIS_METHOD PARTKWAY
LEVEL END
HIER_DEBUG_LEVEL 1
HIER_CHECKS 1
