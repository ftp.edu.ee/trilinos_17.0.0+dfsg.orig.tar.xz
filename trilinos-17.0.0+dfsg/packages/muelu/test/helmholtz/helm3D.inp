20       20       20
0.01     0.01     0.01
0.01     2.0
5        5
5        5
5        5
62.83    0.5
2        2        1
0
