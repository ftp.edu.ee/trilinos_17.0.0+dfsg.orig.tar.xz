80       80       80
0.01     0.01     0.01
0.01     2.0
10       10
10       10
10       10
62.83    0.5
2        2        1
0
